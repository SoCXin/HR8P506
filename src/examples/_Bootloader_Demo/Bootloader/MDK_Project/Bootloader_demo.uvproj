# Keil uVision project Bootloader_demo.uvproj, settings and files
target Bootloader_Demo (ARM-ADS)
  device: HR8P506FHLQ HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: Bootloader_Demo +hex
  c flags: Optim=3
  c misc: --bitband
  c include: ..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ../../../MDK_StartUp/: startup_HR8P506.s
  group CMSIS
    ../../../CMSIS/: HR8P506.h core_cm0.h
  group Source
    ../source/: go.c isp_proc.c lib_flashiap.c main.c systick.c uart.c
