# Keil uVision project App_Systick_demo.uvproj, settings and files
target App_Systick_Demo (ARM-ADS)
  device: HR8P506FHLQ HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: App_Systick_Demo +hex
  c flags: Optim=3
  c misc: --bitband
  c include: ..\source
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ../../../MDK_StartUp/: startup_HR8P506.s
  group CMSIS
    ../../../CMSIS/: core_cm0.h HR8P506.h
  group Source
    ../source/: main.c systick.c
