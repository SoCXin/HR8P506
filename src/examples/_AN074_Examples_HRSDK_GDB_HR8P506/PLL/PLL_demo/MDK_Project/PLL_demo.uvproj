# Keil uVision project PLL_demo.uvproj, settings and files
target PLL_demo (ARM-ADS)
  device: HR8P506FHLQ HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: T16Nx_timer +hex
  c flags: Optim=1
  c misc: --bitband
  c include: ..\..\..\..\CMSIS;..\..\..\..\Library\Include;..\PlatForm;C:\Keil\ARM\INC\HR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ../../../../MDK_StartUp/: startup_HR8P506.s
  group CMSIS
    ../../../../CMSIS/: core_cm0.h HR8P506.h system_HR8P506.c
  group Library
    ../../../../Library/Source/: lib_gpio.c lib_timer.c lib_euart.c lib_iic.c lib_printf.c lib_scs.c lib_scu.c lib_spi.c lib_uart.c lib_wdt.c
  group PlatForm
    ../PlatForm/: irqhandler.c
  group APP
    ../APP/: main.c light.c timer.c
