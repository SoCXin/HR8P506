# Keil uVision project TIMER_demo.uvproj, settings and files
target TIMER_demo (ARM-ADS)
  device: HR8P506FHLQ HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: T32Nx_capture +hex
  c misc: --bitband
  c include: ..\..\..\..\Library\Include;..\..\..\..\CMSIS;..\PlatForm;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ../../../../MDK_StartUp/: startup_HR8P506.s
  group CMSIS
    ../../../../CMSIS/: core_cm0.h HR8P506.h system_HR8P506.c
  group Library
    ../../../../Library/Source/: lib_timer.c lib_gpio.c lib_euart.c lib_iic.c lib_printf.c lib_scs.c lib_scu.c lib_spi.c lib_uart.c lib_wdt.c
  group PlatForm
    ../PlatForm/: irqhandler.c
  group APP
    ../APP/: main.c led.c light.c timer.c
