# IAR project SLEEP_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ES8P506 Eastsoft HR8P506
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\APP; ..\PlatForm; ..\..\..\..\CMSIS; ..\..\..\..\Library\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SLEEP_demo.hex
  ILINK.IlinkOutputFile: SLEEP_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: gpio.c light.c main.c sleep.c systick.c
  group CMSIS
    ../../../../CMSIS/: system_HR8P506.c
  group Library
    ../../../../Library/Source/: lib_gpio.c lib_scs.c lib_scu.c
  group PlatForm
    ../PlatForm/: irqhandler.c
  group StartUp
    ../../../../IAR_StartUp/: startup_hr8p506.s
