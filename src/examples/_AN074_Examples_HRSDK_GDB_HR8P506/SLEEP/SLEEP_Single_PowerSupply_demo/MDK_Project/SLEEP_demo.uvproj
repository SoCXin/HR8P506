# Keil uVision project SLEEP_demo.uvproj, settings and files
target SLEEP_demo (ARM-ADS)
  device: HR8P506FHLQ HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: SLEEP_demo +hex
  c flags: OneElfS=1 wLevel=2
  c misc: --bitband
  c include: ..\..\..\..\CMSIS;..\..\..\..\Library\Include;..\APP;..\PlatForm
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ../../../../MDK_StartUp/: startup_HR8P506.s
  group APP
    ../APP/: gpio.c light.c main.c sleep.c systick.c
  group PlatForm
    ../PlatForm/: irqhandler.c
  group Library
    ../../../../Library/Source/: hr8p506_iap_table.c lib_adc.c lib_euart.c lib_gpio.c lib_iic.c lib_lcd.c lib_led.c lib_printf.c lib_rtc.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c
  group CMSIS
    ../../../../CMSIS/: core_cm0.h HR8P506.h system_HR8P506.c
