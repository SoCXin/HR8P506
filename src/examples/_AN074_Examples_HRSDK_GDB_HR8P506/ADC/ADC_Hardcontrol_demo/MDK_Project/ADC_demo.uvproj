# Keil uVision project ADC_demo.uvproj, settings and files
target ADC_demo (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: test_demo +hex
  c misc: --bitband
  c include: ..\App;..\..\..\..\StarUp;..\..\..\..\Library\Include;..\..\..\..\CMSIS;..\PlatForm
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ../../../../MDK_StartUp/: startup_HR8P506.s
  group CMSIS
    ../../../../CMSIS/: core_cm0.h HR8P506.h system_HR8P506.c
  group Library
    ../../../../Library/Source/: lib_adc.c lib_euart.c lib_gpio.c lib_iic.c lib_lcd.c lib_led.c lib_printf.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c hr8p506_iap_table.c
  group PlatForm
    ../PlatForm/: irqhandler.c
  group APP
    ../APP/: adc.c led.c main.c timer.c
