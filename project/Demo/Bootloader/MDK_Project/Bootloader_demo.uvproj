# Keil uVision project Bootloader_demo.uvproj, settings and files
target Bootloader_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HR8P506FHLQ HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: Bootloader_Demo +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\source;..\..\..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ../../../MDK_StartUp/: startup_HR8P506.s
  group Source
    ../source/: main.c go.c isp_proc.c lib_flashiap.c systick.c uart.c
