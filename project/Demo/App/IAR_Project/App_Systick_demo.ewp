# IAR project App_Systick_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ES8P506 Eastsoft HR8P506
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\source; ..\..\..\Library\Include; ..\..\..\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: App_Systick_demo.hex
  ILINK.IlinkOutputFile: App_Systick_demo.out
  ILINK.IlinkIcfFile: ES8P506.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../CMSIS/: core_cm0.h HR8P506.h
  group Source
    ../source/: main.c systick.c
  group StartUp
    ../../../IAR_StartUp/: startup_hr8p506.s
