# Keil uVision project App_Systick_demo.uvproj, settings and files
target App_Systick_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HR8P506FHLQ HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: App_Systick_Demo +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\source;..\..\..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ../../../MDK_StartUp/: startup_HR8P506.s
  group CMSIS
    ../../../CMSIS/: core_cm0.h HR8P506.h
  group Source
    ../source/: main.c systick.c
