# IAR project ADC_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ES8P506 Eastsoft HR8P506
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Include; ..\..\..\..\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_demo.srec
  ILINK.IlinkOutputFile: ADC_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: adc.c led.c main.c timer.c
  group CMSIS
    ../../../../CMSIS/: core_cm0.h HR8P506.h system_HR8P506.c
  group Library
    ../../../../Library/Source/: hr8p506_iap_table.c lib_adc.c lib_euart.c lib_gpio.c lib_iic.c lib_lcd.c lib_led.c lib_printf.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c
  group PlatForm
    ../PlatForm/: irqhandler.c
  group StartUP
    ../../../../IAR_StartUp/: startup_hr8p506.s
